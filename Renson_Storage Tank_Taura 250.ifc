Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.1]
File name: 0001
Time: 2023-12-04T14:47:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 04 14:47:07 2023 * Host: RENSON-PC64rjMe * Database: C:\Users\naniw\AppData\Local\Temp\7ffb2f03-d42b-4b59-844a-c944a62f6276\63976b0d-8ea1-434d-94c5-fd1eafdeca1f\ifc * Database version: 5507 * Database creation date: Mon Dec 04 14:47:06 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Dec 04 14:47:06 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 04 14:47:06 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: 8mm Head

# IfcTank: Taura 250, Renson_Storage Tank_Taura 250:Taura 250:350514
In: Level 1
Type - Material: Color RGB 138-110-075, Color RGB 030-030-030, Color RGB 043-043-044
Type - Pset_EnvironmentalImpactIndicators - Reference: Taura 250
Type - Pset_ManufacturerTypeInformation - Manufacturer: Renson
Type - Pset_TankTypeCommon - Reference: Taura 250
Type - Pset_ElectricalDeviceCommon - RatedVoltage: 2475.7 A
Pset_EnvironmentalImpactIndicators - sets with these values: 2
